# IAR project video_camera.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; SL_PLATFORM_MULTI_THREADED; ENABLE_LEGECY_PROVISIONING_; USE_FREERTOS; DEBUG_PRINT; RX_RR_TX_SR_
  ICCARM.CCIncludePath2: ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../oslib/; ../../../third_party/ov_sif_inerface/; ../../../third_party/FreeRTOS/source/; ../../../third_party/FreeRTOS/source/include/; ../../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../simplelink_extlib/provisioninglib; ../../../middleware/framework/timer; ../../../middleware/framework/pm; ../../../middleware/driver; ../../../middleware/driver/hal; ../../../middleware/soc; ../../../netapps/rtsp; ../../../netapps/rtp_rtcp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: video_camera.bin
  ILINK.IlinkOutputFile: video_camera.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: cc3200.icf
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/PM_Framework/Exe/simplelink.a; ../../../simplelink_extlib/provisioninglib/ewarm/Release/Exe/provisioninglib.a; ../../../middleware/ewarm/Release/Exe/middleware.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../netapps/rtp_rtcp/ewarm/Release/Exe/rtp_rtcp.a; ../../../netapps/rtsp/ewarm/Release/Exe/rtsp.a; ../../../third_party/ov_sif_inerface/ewarm/Release/Exe/ov_sif_interface.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release_LegacyProvisioning (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; SL_PLATFORM_MULTI_THREADED; ENABLE_LEGECY_PROVISIONING; USE_FREERTOS; DEBUG_PRINT; RX_RR_TX_SR_
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/PM_Framework/Exe/simplelink.a; ../../../middleware/ewarm/Release/Exe/middleware.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../netapps/rtp_rtcp/ewarm/Release/Exe/rtp_rtcp.a; ../../../netapps/rtsp/ewarm/Release/Exe/rtsp.a; ../../../third_party/ov_sif_inerface/ewarm/Release/Exe/ov_sif_interface.a
  group (top)
    ../: audio_tx_task.c cc_pal_app.c fs_if.c get_av_task.c lp3p0_board.c lp3p0_plat_ops.c main.c pinmux.c provisioning.c rtsp_main_task.c video_tx_task.c
    ../../common/: network_common.c startup_ewarm.c timer_if.c uart_if.c utils_if.c
