# IAR project rtp_rtcp.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; SL_PLATFORM_MULTI_THREADED; USE_FREERTOS; DEBUG_PRINT_
  ICCARM.CCIncludePath2: ..\..\..\oslib\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: rtp_rtcp.out
  group (top)
    ../: rtcp_rtp.c
