<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\third_party\ov_sif_inerface\ewarm\ov_sif_interface.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\netapps\rtp_rtcp\ewarm\rtp_rtcp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\netapps\rtsp\ewarm\rtsp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\video_camera.ewp</path>
  </project>
  <batchBuild/>
</workspace>


